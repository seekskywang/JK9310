# Keil uVision project project.uvprojx, settings and files
target Open1788 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC1788 NXP
  pack: Keil.LPC1700_DFP.2.6.0
  cpu: IRAM(0x10000000,0x10000) IRAM2(0x20000000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_FULL_LL_DRIVER
  c misc: --locale=english
  c include: ..\Libraries\Core\CM3\CoreSupport;..\Libraries\Core\CM3\DeviceSupport\NXP\LPC177x_8x;..\Libraries\Drivers\include;..\User;..\Libraries\BoardSupport;..\User\UseDisp;..\User\Globalvalue;..\Libraries\Drivers\include;..\User\Include;..\User\Fat;..\User\Host;..\User\MassStorage;..\User\pwm;..\User\spi_ad_da;..\User\FATFS_V0.08A\src;..\User\touch;..\emWin\Config;..\emWin\Header;..\emWin\Library;..\emWin;..\User\flash;..\User\Test;..\libscpi\inc
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group User
    ../User/EX_SDRAM/: EX_SDRAM.c
    ../User/: main.c timer.c GUI_FONTXBFFON16.c GUI_FONTXBFFON50.c CPLD.c GUI_FONTXBFFON32.c HZMCRBLK16.c scpi-def.c
    ../User/LCD/: lpc177x_8x_lcd.c logo.c AsciiLib.c
    ../User/UseDisp/: use_disp.c
    ../User/Key/: key.c
    ../User/Test/: test.c Debug.c
    ../User/Globalvalue/: GlobalValue.c
    ../User/pwm/: pwm.c
    ../User/spi_ad_da/: spi_da_ad.c
  group Startup
    ../Libraries/Core/CM3/DeviceSupport/NXP/LPC177x_8x/startup/arm/: startup_LPC177x_8x.s
  group CMSIS-CMS
    ../Libraries/Core/CM3/DeviceSupport/NXP/LPC177x_8x/: system_LPC177x_8x.c
    ../Libraries/Core/CM3/CoreSupport/: core_cm3.c
  group Drivers
    ../Libraries/Drivers/source/: lpc177x_8x_gpio.c lpc177x_8x_systick.c lpc177x_8x_clkpwr.c lpc177x_8x_uart.c debug_frmwrk.c lpc177x_8x_pinsel.c lpc177x_8x_eeprom.c lpc177x_8x_rtc.c lpc177x_8x_pwm.c lpc177x_8x_emc.c lpc177x_8x_ssp.c
  group fat
    ../User/Fat/: usbhost_fat.c
  group host
    ../User/Host/: usbhost_lpc17xx.c
  group MassStorage
    ../User/MassStorage/: usbhost_ms.c
  group FATFS_V0.08A
    ../User/FATFS_V0.08A/src/: diskio.c ff.c
  group emWin/Config
    ../emWin/Config/: GUIConf.c LCDConf.c SIMConf.c GUI_X.c
  group emWin/Library
    ../emWin/Library/: GUI_CM3_L.lib
  group emWin/Header
    ../emWin/Header/: BUTTON.h CHECKBOX.h CHOOSECOLOR.h CHOOSEFILE.h DIALOG.h DIALOG_Intern.h DROPDOWN.h EDIT.h FRAMEWIN.h Global.h GRAPH.h GUI.h GUI_ARRAY.h GUI_ConfDefaults.h GUI_Debug.h GUI_FontIntern.h GUI_HOOK.h GUI_Private.h GUI_SetOrientation.h GUI_SetOrientationCX.h GUI_Type.h GUI_Version.h GUI_VNC.h GUIDRV_BitPlains.h GUIDRV_DCache.h GUIDRV_Dist.h GUIDRV_FlexColor.h GUIDRV_Generic.h GUIDRV_IST3088.h GUIDRV_Lin.h GUIDRV_NoOpt_1_8.h GUIDRV_S1D15G00.h GUIDRV_S1D13748.h GUIDRV_SLin.h GUIDRV_SPage.h GUIDRV_SSD1926.h GUIDRV_Template.h GUIDRV_TemplateI.h HEADER.h ICONVIEW.h IMAGE.h LCD.h LCD_ConfDefaults.h LCD_Protected.h LCD_SIM.h LISTBOX.h LISTVIEW.h LISTWHEEL.h MENU.h MESSAGEBOX.h MULTIEDIT.h MULTIPAGE.h PROGBAR.h RADIO.h SCROLLBAR.h SLIDER.h SPINBOX.h TEXT.h TREEVIEW.h WIDGET.h WM.h WM_GUI.h WM_Intern.h
  group flash
    ../User/flash/: AT45DB.c
  group libscpi
    ../libscpi/src/: error.c expression.c fifo.c fifo_private.h ieee488.c lexer.c lexer_private.h minimal.c parser.c parser_private.h units.c utils.c utils_private.h
software components: CMSIS:CORE 5.0.1
